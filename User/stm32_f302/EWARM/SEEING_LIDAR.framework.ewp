# IAR project SEEING_LIDAR.framework.ewp, settings and files
configuration SEEING_LIDAR.framework (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302C8 ST STM32F302C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302x8
  ICCARM.CCIncludePath2: ..\..\..\Global; ..\..\..\Platform\STM32Cube_FW_F3_V1.9.0\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\Platform\STM32Cube_FW_F3_V1.9.0\CMSIS\Include; ..\..\..\Platform\STM32Cube_FW_F3_V1.9.0\STM32F3xx_HAL_Driver\Inc; ..\..\..\System\FreeRTOSv9.0.0\FreeRTOS\Source\include; ..\..\..\System\FreeRTOSv9.0.0\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..; ..\Drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Drivers
  OBJCOPY.OOCOutputFile: SEEING_LIDAR.framework.bin
  ILINK.IlinkOutputFile: SEEING_LIDAR.framework.out
  ILINK.IlinkIcfFile: stm32f302x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Common
    ../../../Common/: Scheduler.c String.c Time.c Types.h
  group Config
    ../../../Config/: Config.h
  group Global
    ../../../Global/: Include.h Initial.c Startup.c
  group Platform/STM32Cube_FW_F3_V1.9.0/CMSIS
    ../../../Platform/STM32Cube_FW_F3_V1.9.0/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f302x8.s
    ../../../Platform/STM32Cube_FW_F3_V1.9.0/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Platform/STM32Cube_FW_F3_V1.9.0/STM32F3xx_HAL_Driver
    ../../../Platform/STM32Cube_FW_F3_V1.9.0/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group System
    ../../../System/: cmsis_os.c
  group System/FreeRTOS/Source
    ../../../System/FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group System/FreeRTOS/Source/portable
    ../../../System/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../System/FreeRTOSv9.0.0/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group User
    ../: Applications.c Drivers.c
  group User/Drivers
    ../Drivers/: FreeRTOSConfig.h stm32f3xx_hal_conf.h stm32f3xx_hal_msp.c stm32f3xx_it.c stm32f3xx_it.h
